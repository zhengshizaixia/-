# Keil uVision project WIFI_LED.uvprojx, settings and files
target WIFI_LED (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x200007FF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: WIFI_LED +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L011xx
  c include: ../Core/Inc;     ../Drivers/STM32L0xx_HAL_Driver/Inc;     ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;     ../Drivers/CMSIS/Include;     ..\User\Application;     ..\User\Driver\MCU Driver;     ..\User\Driver\Peripheral Driver;     ..\User\FrameWork;     ..\User\Function;     ..\User\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Application/MDK-ARM
    ./: startup_stm32l011xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group APP
    ../User/Application/: ApplicationMain.c ApplicationMain.h
  group Function
    ../User/Function/: FunctionMain.c FunctionMain.h
  group MCUDriver
    ../User/Driver/MCU Driver/: LEDGPIO.c LEDGPIO.h SPI2.c SPI2.h Uart2.c Uart2.h
  group PeripheralDriver
    ../User/Driver/Peripheral Driver/: LEDConfig.c LEDConfig.h PeripheralMain.c PeripheralMain.h WS2812Config.c WS2812Config.h
  group FrameWork
    ../User/FrameWork/: LEDControl.c LEDControl.h WS2812.c WS2812.h
  group RTT
    ../User/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
